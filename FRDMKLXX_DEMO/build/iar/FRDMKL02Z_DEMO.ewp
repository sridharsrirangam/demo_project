# IAR project FRDMKL02Z_DEMO.ewp, settings and files
configuration FLASH_32KB_KL02 (ARM, debug)
  General.OGChipSelectEditMenu: MKL02Z32xxx4 Freescale MKL02Z32xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; FREEDOM
  ICCARM.CCIncludePath2: ..\..\src\mcu_init\common; ..\..\src\mcu_init\cpu; ..\..\src\mcu_init\cpu\headers; ..\..\src\mcu_init\drivers\uart; ..\..\src\mcu_init\drivers\mcg; ..\..\src\mcu_init\drivers\wdog; ..\..\src\mcu_init\platforms; includes; ..\..\src; ..\..\src\frdmkl02z48m; ..\..\..\..\GUI\source\src_common; ..\..\..\..\GUI\source\src_platforms\Kxx; ..\..\..\..\LIB\lib_iar; ..\..\..\..\LIB\shared; ..\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FRDMKL02Z_DEMO.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: config files\32KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Headers
    ../../src/frdmkl02z48m/: derivative.h MKL02Z4.h
  group Mcu_Init/common
    ../../src/mcu_init/common/: common.h startup.c startup.h
  group Mcu_Init/cpu
    ../../src/mcu_init/cpu/: arm_cm0.c arm_cm0.h crt0_cm0.s start.c start.h sysinit.h sysinit_kl02.c vectors.c vectors.h
  group Mcu_Init/drivers/mcg
    ../../src/mcu_init/drivers/mcg/: mcg_kl02.c mcg_kl02.h
  group Mcu_Init/drivers/uart
    ../../src/mcu_init/drivers/uart/: uart_kl05.c uart_kl05.h
  group Mcu_Init/drivers/wdog
    ../../src/mcu_init/drivers/wdog/: wdog.h wdog_kl25.c
  group Sources
    ../../src/: freemaster_cfg.h main.c main.h TSS_SystemSetupGlobal.h
    ../../src/frdmkl02z48m/: isr.h TSS_SystemSetup.h
  group Sources/App_Init
    ../../src/: app_init.c app_init.h
  group Sources/Board
    ../../src/frdmkl02z48m/: board.c board.h
  group Sources/Events
    ../../src/: events.c events.h
  group Sources/FreeMASTER
    ../../../../GUI/source/src_platforms/Kxx/: freemaster.h freemaster_Kxx.c
    ../../../../GUI/source/src_common/: freemaster_appcmd.c freemaster_can.c freemaster_protocol.c freemaster_rec.c freemaster_scope.c freemaster_serial.c freemaster_sfio.c freemaster_tsa.c
  group Sources/TSS
    ../../../../LIB/shared/: TSS_API.h TSS_DataTypes.h TSS_Freemaster.c TSS_GPIO.h TSS_Sensor.c TSS_Sensor.h TSS_SensorGPIO.c TSS_SensorGPIO.h TSS_SensorTSI.c TSS_SensorTSI.h TSS_SensorTSIL.c TSS_SensorTSIL.h TSS_StatusCodes.h TSS_SystemSetupData.c TSS_SystemSetupVal.h TSS_Timer.h
    ../../../../LIB/lib_iar/: TSS_KXX_M0.a
