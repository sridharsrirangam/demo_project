# Keil uVision project FRDMKL25Z_DEMO.uvprojx, settings and files
target FRDMKL25Z_DEMO (ARM-ADS)
  device: MKL25Z32xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.4.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x1FFFFC00,0x1000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: TWRKL25Z48M_DEMO
  c define: FREEDOM, FRDM_KL25Z48
  c include: ..\..\..\src;..\..\..\src\mcu_init\cpu;..\..\..\src\mcu_init\drivers\uart;..\..\..\src\mcu_init\drivers\wdog;..\..\..\src\module_id;..\..\..\src\frdmkl25z48m;..\..\..\..\..\GUI\source\src_common;..\..\..\..\..\GUI\source\src_platforms\Kxx;..\..\..\..\..\LIB\shared;..\..\..\..\..\LIB\lib_uv4;..\..\..\src\mcu_init\common;..\..\..\src\mcu_init\cpu;..\..\..\src\mcu_init\platforms;..\..\..\src\mcu_init\drivers\mcg
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x1000
  group App_Init
    ../../../src/: app_init.c app_init.h
  group Events
    ../../../src/: events.c events.h
  group FreeMASTER
    ../../../../../GUI/source/src_common/: freemaster_appcmd.c freemaster_bdm.c freemaster_can.c freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_serial.c freemaster_tsa.c
    ../../../../../GUI/source/src_platforms/Kxx/: freemaster.h freemaster_Kxx.c freemaster_Kxx.h
  group Mcu_Init
    ../../../src/mcu_init/common/: common.h
    ../../../src/mcu_init/cpu/: arm_cm0.c arm_cm0.h sysinit.h sysinit_kl25.c
    ../../../src/mcu_init/drivers/wdog/: wdog.h wdog_kl25.c
    ../../../src/mcu_init/drivers/mcg/: mcg_kl25.c mcg_kl25.h
    ../../../src/mcu_init/drivers/uart/: uart_kl25.c uart_kl25.h
  group TSS
    ../../../../../LIB/shared/: TSS_API.h TSS_DataTypes.h TSS_Freemaster.c TSS_GPIO.h TSS_Sensor.c TSS_Sensor.h TSS_SensorGPIO.c TSS_SensorGPIO.h TSS_SensorTSI.c TSS_SensorTSI.h TSS_SensorTSIL.c TSS_SensorTSIL.h TSS_StatusCodes.h TSS_SystemSetupData.c TSS_SystemSetupVal.h TSS_Timer.h
    ../../../../../LIB/lib_uv4/: TSS_KXX_M0.lib
  group Sources
    ../../../src/: freemaster_cfg.h main.c main.h
    ../../../src/frdmkl25z48m/: isr.h TSS_SystemSetup.h
  group Project_Headers
    ../../../src/frdmkl25z48m/: derivative.h MKL25Z4.h
  group Startup_Code
    ./: startup_MKL25Z4.s system_MKL25Z4.c
  group Board
    ../../../src/frdmkl25z48m/: board.c board.h
  group accel
    ../../../src/: delay.c i2c.c LEDs.c mma8451.c delay.h GPIO_defs.h i2c.h LEDs.h mma8451.h timers.c timers.h
